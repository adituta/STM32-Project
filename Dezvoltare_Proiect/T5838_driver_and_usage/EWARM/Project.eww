<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\T5838_driver_and_usage.ewp</path>
  </project>
  <batchBuild />
</workspace>
